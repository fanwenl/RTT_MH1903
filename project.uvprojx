# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin !L -o $L@L.bin
  AfterMake: .\tools\copy_file.bat
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c misc: --no-multibyte-chars
  c include: applications;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m4;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;board;board\ports;packages\fal-v0.5.0\inc;packages\fastlz-v1.0.1;rt-thread\components\dfs\include;rt-thread\components\dfs\filesystems\devfs;rt-thread\components\finsh;.;rt-thread\include;rt-thread\components\libc\compilers\common;rt-thread\components\libc\compilers\common\nogcc;libraries\MHSCPU_Driver\inc;libraries\CMSIS\Include;libraries\Device\MegaHunt\mhscpu\Include;packages\ota_downloader-v1.0.0;rt-thread\components\libc\posix\io\poll;rt-thread\components\libc\posix\ipc;packages\quicklz-v1.0.1;packages\tinycrypt-v1.0.0\include;rt-thread\components\utilities\ulog;rt-thread\components\utilities\ymodem
  memory RVCT4: ROM 0x1001000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group CPU
    rt-thread/libcpu/arm/common/: div0.c backtrace.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/misc/: rt_drv_pwm.c pin.c
    rt-thread/components/drivers/mtd/: mtd_nor.c
    rt-thread/components/drivers/rtc/: rtc.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/src/: completion.c workqueue.c ringblk_buf.c dataqueue.c pipe.c ringbuffer.c waitqueue.c
    rt-thread/components/drivers/watchdog/: watchdog.c
  group Drivers
    board/: drv_gpio.c drv_usart.c drv_wdt.c drv_flash.c drv_rtc.c drv_pwm.c board.c
  group fal
    packages/fal-v0.5.0/src/: fal_rtt.c fal_partition.c fal_flash.c fal.c
  group fastlz
    packages/fastlz-v1.0.1/: fastlz.c
  group Filesystem
    rt-thread/components/dfs/src/: dfs_posix.c dfs_fs.c dfs.c dfs_file.c
    rt-thread/components/dfs/filesystems/devfs/: devfs.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_file.c cmd.c
  group Kernel
    rt-thread/src/: clock.c timer.c components.c signal.c object.c memheap.c device.c kservice.c irq.c mempool.c idle.c scheduler.c ipc.c thread.c
  group Libraries
    libraries/MHSCPU_Driver/src/: mhscpu_dcmi.c misc.c mhscpu_timer.c mhscpu_cache.c mhscpu_uart.c mhscpu_qspi.c mhscpu_dma.c mhscpu_wdt.c mhscpu_rtc.c mhscpu_i2c.c mhscpu_exti.c mhscpu_sysctrl.c mhscpu_gpio.c
    libraries/Device/MegaHunt/mhscpu/Source/: system_mhscpu.c
    libraries/Device/MegaHunt/mhscpu/Source/ARM/: startup_mhscpu.s
  group ota_downloader
    packages/ota_downloader-v1.0.0/src/: ymodem_ota.c
  group quicklz
    packages/quicklz-v1.0.1/: quicklz.c
  group TinyCrypt
    packages/tinycrypt-v1.0.0/src/: tiny_aes.c tiny_md5.c tiny_sha1.c tiny_sha2.c tiny_base64.c
  group Utilities
    rt-thread/components/utilities/ulog/backend/: console_be.c
    rt-thread/components/utilities/ulog/: ulog.c
    rt-thread/components/utilities/ymodem/: ry_sy.c ymodem.c
