# Keil uVision project template.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin !L -o $L@L.bin
  AfterMake: .\tools\copy_file.bat
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --no-multibyte-chars
  memory RVCT4: ROM 0x1001000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
