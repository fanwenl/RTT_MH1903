# Keil uVision project project.uvprojx, settings and files
target bootloader (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: bootloader +hex
  AfterMake: fromelf --bin !L -o $L@L.bin
  AfterMake: ..\..\tools\copy_file.bat boot
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, LFS_CONFIG=lfs_config.h, RT_USING_ARM_LIBC, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c include: ..\src;..\..\rt-thread\libcpu\arm\common;..\..\rt-thread\libcpu\arm\cortex-m4;..\..\rt-thread\components\drivers\include;..\..\board;..\..\board\ports;..\..\packages\fal-v0.5.0\inc;..\..\packages\fastlz-v1.0.1;..\..\rt-thread\components\finsh;..\..\rt-thread\include;..\..\rt-thread\components\libc\compilers\common;..\..\rt-thread\components\libc\compilers\common\nogcc;..\..\libraries\MHSCPU_Driver\inc;..\..\libraries\CMSIS\Include;..\..\libraries\Device\MegaHunt\mhscpu\Include;..\..\packages\ota_downloader-v1.0.0;..\..\packages\quicklz-v1.0.1;..\..\packages\tinycrypt-v1.0.0\include;..\..\rt-thread\components\utilities\ulog;..\..\rt-thread\components\utilities\ymodem;..\..\packages\CmBacktrace-v1.4.0
  memory RVCT4: ROM 0x1001000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\src\boot_link.sct
  group Applications
    ../src/: main.c rt_fota.c rt_fota_crc.c
  group CPU
    ../../rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
    ../../rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group DeviceDrivers
    ../../rt-thread/components/drivers/serial/: serial.c
    ../../rt-thread/components/drivers/mtd/: mtd_nor.c
    ../../rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../rt-thread/components/drivers/misc/: pin.c
  group Drivers
    ../../board/: board.c drv_flash.c drv_gpio.c drv_rtc.c drv_usart.c
  group fal
    ../../packages/fal-v0.5.0/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
  group fastlz
    ../../packages/fastlz-v1.0.1/: fastlz.c
  group Finsh
    ../../rt-thread/components/finsh/: cmd.c msh.c msh_file.c shell.c
  group Kernel
    ../../rt-thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group libc
    ../../rt-thread/components/libc/compilers/armlibc/: libc_syms.c mem_std.c syscalls.c
    ../../rt-thread/components/libc/compilers/common/: stdlib.c time.c
  group Libraries
    ../../libraries/MHSCPU_Driver/src/: mhscpu_qspi.c mhscpu_uart.c misc.c mhscpu_dma.c mhscpu_cache.c mhscpu_gpio.c mhscpu_exti.c mhscpu_sysctrl.c mhscpu_rtc.c
    ../../libraries/Device/MegaHunt/mhscpu/Source/: system_mhscpu.c
    ../../libraries/Device/MegaHunt/mhscpu/Source/ARM/: startup_mhscpu.s
  group ota_downloader
    ../../packages/ota_downloader-v1.0.0/src/: ymodem_ota.c
  group quicklz
    ../../packages/quicklz-v1.0.1/: quicklz.c
  group TinyCrypt
    ../../packages/tinycrypt-v1.0.0/src/: tiny_aes.c tiny_base64.c tiny_md5.c tiny_sha1.c tiny_sha2.c
  group Utilities
    ../../rt-thread/components/utilities/ulog/: ulog.c
    ../../rt-thread/components/utilities/ulog/backend/: console_be.c
    ../../rt-thread/components/utilities/ymodem/: ymodem.c
